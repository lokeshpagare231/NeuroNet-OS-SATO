# Remove gtk-theme-switch since it is no longer available
IMAGE_INSTALL:remove = "gtk-theme-switch"
